# Keil uVision project Blance_DEMO.uvprojx, settings and files
target Blance_DEMO (6180000::V6.18::ARMCLANG)
  device: STM32H723VETx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00050000) IROM(0x08000000,0x00100000) XRAM(0x30000000,0x00008000) XRAM2(0x38000000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Blance_DEMO +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER,STM32H723xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../User/Bsp;../User/Algorithm/EKF;../User/Devices/BMI088;../User/Algorithm/kalman;../User/Algorithm/mahony;../User/APP;../RM_File;../MDK-ARM;../User/Devices/BMMotor
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x8000
  memory RVCT7: RAM 0x38000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Algorithm
    ../User/Algorithm/mahony/: mahony_filter.c
    ../User/Algorithm/EKF/: QuaternionEKF.c
    ../User/Algorithm/kalman/: kalman_filter.c
  group BSP
    ../User/Bsp/: bsp_dwt.c bsp_PWM.c
    ../RM_File/: ch_gyro_232.h DM.h ladrc.h MF9025.h RM_Can.h RM_CHxxxGy.h RM_Clicker.h RM_Filter.h RM_Key.h RM_Motor.h RM_Pid.h RM_PM01.h RM_RefereeSystem.h RM_RefereeSystemCRC.h RM_Servos.h RM_StaticTime.h RM_stdxxx.h RM_stm32fxxx_hal.h RM_Wheel.h VMC.h RM_RefereeSystem.cpp RM_RefereeSystemCRC.cpp
  group MBI088
    ../User/Devices/BMI088/: BMI088driver.c BMI088Middleware.c
  group INS
    ../User/APP/: INS_task.c
  group APP
    ../RM_File/: def_variable.h Total_stack.h
    ./: Total_stack.cpp
  group Motor
    ../User/Devices/BMMotor/: BMMotor.hpp MotorBase.hpp
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.15.0
